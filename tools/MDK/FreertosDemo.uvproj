# Keil uVision project FreertosDemo.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FreertosDemo
  AfterMake: fromelf --bin ".\out\@L.axf" --output ".\bin\@L.bin"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\src\lib\FreeRTOS\include;..\..\src\lib\FreeRTOS\portable\MemMang;..\..\src\lib\FreeRTOS\portable\RVDS\ARM_CM3;..\..\src\lib\STM32FLib\STM32F10x_StdPeriph_Driver\inc;..\..\src\lib\STM32FLib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\src\lib\STM32FLib\CMSIS\CM3\CoreSupport;..\..\src\config;..\..\src\drivers\interface;..\..\src\hal\interface;..\..\src\modules\interface;..\..\src\utils\debug;..\..\src\utils\delay;..\..\src\utils\eprintf;..\..\src\utils\fifo;..\..\src\platform
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ../../src/init/: main.c
    ../../src/drivers/src/: serial.c led.c uart2.c key.c rf.c lcd1602.c AT24LC32.c
    ../../src/utils/eprintf/: eprintf.c
    ../../src/utils/fifo/: app_fifo.c
    ../../src/utils/delay/: delay.c
    ../../src/platform/meshTools/: platform_meshTools.c
    ../../src/modules/src/: system.c AT_option.c stm32f10x_it.c
  group CMSIS
    ../../src/lib/STM32FLib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../src/lib/STM32FLib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../../src/lib/STM32FLib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group FreeRtos
    ../../src/lib/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../src/lib/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../../src/lib/FreeRTOS/portable/MemMang/: heap_2.c
  group STM32Lib
    ../../src/lib/STM32FLib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
